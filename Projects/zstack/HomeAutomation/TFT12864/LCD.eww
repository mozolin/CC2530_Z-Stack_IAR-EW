<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OLED12864.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TFT12864.ewp</path>
    </project>
    <batchBuild />
</workspace>
