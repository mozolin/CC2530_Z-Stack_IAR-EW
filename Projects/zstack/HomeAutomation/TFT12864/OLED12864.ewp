# IAR project OLED12864.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDiagSuppress: Pe128
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: code\common; code\HW_LCD\HAL_OLED; code\HW_LCD\HAL_LCD_SPI\SPI_Driver; code\HW_LCD\HAL_LCD_SPI; code\HW_LCD\Font
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    code/OLED12864/: main.c
  group Common
    code/common/: cc2530_ioctl.h hal_delay.c hal_delay.h
  group HAL_LCD_SPI
    code/HW_LCD/HAL_LCD_SPI/: hal_lcd_spi.c hal_lcd_spi.h
  group HAL_LCD_SPI/SPI_Driver
    code/HW_LCD/HAL_LCD_SPI/SPI_Driver/: hw_spi.c hw_spi.h spi_common.h sw_spi.c sw_spi.h
  group OLED12864
    code/HW_LCD/Font/: font_chinese_v_16x16.h font_v_8x16.h font_v_picture.h
    code/HW_LCD/HAL_OLED/: hal_oled12864.c hal_oled12864.h
